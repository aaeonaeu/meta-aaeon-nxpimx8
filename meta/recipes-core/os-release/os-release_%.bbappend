FILESEXTRAPATHS:prepend := "${THISDIR}/os-release:"

SRC_URI += " \
            file://os-release \
"

